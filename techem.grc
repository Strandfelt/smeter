options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: top_block
    output_language: python
    realtime_scheduling: '1'
    run_options: run
  states: {}

blocks:
- name: channel_spacing
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: demodgain
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: (channel_spacing / 2) + (channel_spacing * .1)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.024e6
  states: {}
- name: squelch
  id: variable
  parameters:
    value: '-25'
  states: {}
- name: tuner
  id: variable
  parameters:
    value: 868.95e6
  states: {}
- name: width
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: demodgain
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: capture
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-freq_offset'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate,cutoff, width,  firdes.WIN_BLACKMAN, 6.76)
    type: ccc
  states: {}
- name: osmosdr_source_0_1
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    corr0: '21'
    freq0: tuner+freq_offset
    gain0: '10'
    gain_mode0: '0'
    if_gain0: '24'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', analog_simple_squelch_cc_0, '0']
- [osmosdr_source_0_1, '0', freq_xlating_fir_filter_xxx_0_1, '0']

metadata:
  file_format: 1
